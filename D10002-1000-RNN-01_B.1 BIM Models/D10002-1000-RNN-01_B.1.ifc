Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2026-03-17T00:37:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 17 00:37:05 2026 * Host: Yoga * Database: D:\Temp\ba28f502-3be8-4f53-a906-ba9e9b79f889\f13b32e4-6792-41af-8761-4b32880e46a4\ifc * Database version: 5507 * Database creation date: Tue Mar 17 00:37:03 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 17 00:37:04 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 17 00:37:04 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Constraints(Type) - Elevation Base: Project Base Point
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum

# IfcFlowController: DB3100:DB3100, DB3100:DB3100:468781
In: Level 0
Type - PredefinedType: MIXING; Material: Default
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_78:Shower manual water supply sets; CodePerformance: WRAS_TMV2; Color: Various; Constituents: n/a; Description: ShowerValveAndTwoWayDiverter; DurationUnit: year; ExpectedLife: n/a; Features: DB3100_Lever_DB3101_Leverless; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel_.5/PowderCoated_.6/CeramicCoated; Grade: Various_316SS; IfcExportAs: IfcValveType; IfcExportType: MIXING; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Valve/Brass_FacePlate/StainlessSteel; ModelNumber: DB3100/DB3101; ModelReference: DolphinSolutionsLimited_ShowerManualWaterSupplySets_ShowerValveAndTwoWayDiverter; Name: ShowerManualWaterSupplySets_ShowerValveAndTwoWayDiverter_DB3100_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 215 mm; NominalLength: 45 mm; NominalWidth: 130 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-shower-valve/; ReplacementCost: n/a; Shape: Rectangular; Size: 130x215x45; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3100; Uniclass2015Code: Pr_40_20_87_78; Uniclass2015Title: Shower manual water supply sets; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 5; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Materials and Finishes - Primary Material: Default; Secondary Material: Default
Type - Other - Category: Plumbing Fixtures; Family Name: DB3100
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ShowerManualWaterSupplySets_ShowerValveAndTwoWayDiverter; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerManualWaterSupplySets_ShowerValveAndTwoWayDiverter_DB3100_DolphinSolutionsLimited; Category: Pr_40_20_87_78:Shower manual water supply sets
Pset_DistributionFlowElementCommon - Reference: DB3100:DB3100; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 750 mm; Host: Level : Level 0; Offset from Host: 750 mm
Dimensions - Area: 0.0423619 m2; Volume: 0.000242714 m3
Identity Data - Mark: 187
Other - Family: DB3100: DB3100; Family and Type: DB3100: DB3100; Type: DB3100: DB3100; Type Id: DB3100: DB3100
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5023-07SS:Standard (2)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 800 mm; Height: 140 mm; Width: 100 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182_DocM_BS8300; Color: Brushed Satin Polished-PSS; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: 800mm Fold Down; Finish: Brushed Satin/ Polished-PSS; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5023-07SS/BC5023-07-PSS; ModelReference: DolphinSolutionsLimited_32mmGrabRail; Name: SupportRails_800mmFoldDown32mmGrabRail_BC5023-07SS_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 139 mm; NominalLength: 800 mm; NominalWidth: 100 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-contemporary-grab-rail/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 800 x 100 x 139 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5023-07SS
Type - Pset_ElementShading - Color: Brushed Satin Polished-PSS
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_32mmGrabRail
Type - Pset_ProductRequirements - Name: SupportRails_800mmFoldDown32mmGrabRail_BC5023-07SS_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Pset_DistributionFlowElementCommon - Reference: BC5023-07SS:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 567.285 mm; Host: Level : Level 0; Offset from Host: 567.285 mm
Dimensions - Area: 0.0683182 m2; Volume: 0.000693445 m3
Other - Family: BC5023-07SS: Standard; Family and Type: BC5023-07SS: Standard; Type: BC5023-07SS: Standard; Type Id: BC5023-07SS: Standard
Phasing - Phase Created: New Construction
Name (BC5023-07SS:Standard:...) | Mark
468698 | 151
468703 | 156

# IfcFlowTerminal: BC5063-02:Standard (3)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - Depth: 76 mm; Diameter: 32 mm; Width: 600 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182; Color: Brushed Satin; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Roseless 60mm wall clearance; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5063-02; ModelReference: DolphinSolutionsLimited_Roseless32mmGrabRail; Name: SupportRails_Roseless32mmGrabRail_BC5063-02_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 92 mm; NominalLength: 600 mm; NominalWidth: 32 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-roseless-stainless-steel-grab-rail-32mm/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 600 x 32 x 92 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5063-02
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Roseless32mmGrabRail
Type - Pset_ProductRequirements - Name: SupportRails_Roseless32mmGrabRail_BC5063-02_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Pset_DistributionFlowElementCommon - Reference: BC5063-02:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Host: Level : Level 0
Dimensions - Area: 0.0662086 m2; Volume: 0.00013204 m3
Other - Family: BC5063-02: Standard; Family and Type: BC5063-02: Standard; Type: BC5063-02: Standard; Type Id: BC5063-02: Standard
Phasing - Phase Created: New Construction
Name (BC5063-02:Standard:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
468699 | 665 | 152
468700 | 665 | 153
468705 | 1100 | 158

# IfcFlowTerminal: BC5083-101:Standard, BC5083-101:Standard:468702
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 10 mm; Height: 1000 mm; Width: 400 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_25_71_53_06:Bathroom mirrors; CodePerformance: n/a; Color: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Form: Wall-mounted; Grade: n/a; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Glass; ModelNumber: BC5083-101; ModelReference: DolphinSolutionsLimited_Mirror; Name: BathroomMirrors_Mirror_BC5083-101_DolphinSolutionsLimited; NBSDescription: Bathroom mirrors; NBSReference: 45-35-72/336; NBSTypeID: n/a; NominalHeight: 1000; NominalLength: 15; NominalWidth: 400; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.95.17.17; OmniClass Number: 23.45.05.21.11; OmniClass Title: Water Closets; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 400 x 1000 x 15 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_25_71_53_06; Uniclass2015Title: Bathroom mirrors; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-101
Type - Pset_ElementShading - Color: n/a
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Mirror
Type - Pset_ProductRequirements - Name: BathroomMirrors_Mirror_BC5083-101_DolphinSolutionsLimited; Category: Pr_25_71_53_06:Bathroom mirrors
Pset_DistributionFlowElementCommon - Reference: BC5083-101:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 600 mm; Host: Level : Level 0; Offset from Host: 600 mm
Dimensions - Area: 0.827875 m2; Volume: 0.004 m3
Identity Data - Mark: 155
Other - Family: BC5083-101: Standard; Family and Type: BC5083-101: Standard; Type: BC5083-101: Standard; Type Id: BC5083-101: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-121:Standard, BC5083-121:Standard:468701
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 2500 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_75_75_04_04:AssistanceCallPulCordUnits; CodePerformance: BS8300:DocM; Color: Brushed Satin; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: BS8300:DocM_PullCord_OpenDoorIndicator_ResetButton; Finish: Brushed Satin; Form: Surface-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-121; ModelReference: DolphinSolutionsLimited_AssistanceCallPulCordUnit; Name: AssistanceCallPulCordUnits_AssistanceCallPulCordUnit_BC5083-121_DolphinSolutionsLimited; NBSDescription: AssistanceCallPulCordUnits; NBSReference: 90-70-05/320; NBSTypeID: n/a; NominalHeight: 0; NominalLength: 0; NominalWidth: 0; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.85.30.24.11; Operation: PullCord; ProductInformation: https://www.nationalbimlibrary.com/en-gb/vox-ignis-limited/vilx-cpp-assist-call-pull-cord-plate/?lo=en-GB; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_75_75_04_04; Uniclass2015Title: AssistanceCallPulCordUnits; Uniclass2015Version: Products v1.15; Version: 1; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-121
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_AssistanceCallPulCordUnit
Type - Pset_ProductRequirements - Name: AssistanceCallPulCordUnits_AssistanceCallPulCordUnit_BC5083-121_DolphinSolutionsLimited; Category: Pr_75_75_04_04:AssistanceCallPulCordUnits
Pset_DistributionFlowElementCommon - Reference: BC5083-121:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 0 mm; Host: Level : Level 0; Offset from Host: 0 mm
Dimensions - Area: 0.0221672 m2; Volume: 0.000127718 m3
Identity Data - Mark: 154
Other - Family: BC5083-121: Standard; Family and Type: BC5083-121: Standard; Type: BC5083-121: Standard; Type Id: BC5083-121: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC725:BC725 (2)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_78_15:Clothes hooks; CodePerformance: n/a; Color: Brushed Satin or RALPowderCoated; Constituents: n/a; Description: Clothes hooks; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin or RALPowderCoated; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC725/BC725PC; ModelReference: DolphinSolutionsLimited_ClothesHooks; Name: Clothes hooks_BC725_DolphinSolutionsLimited; NBSDescription: Clothes hooks; NBSReference: 45-35-72/322; NBSTypeID: n/a; NominalHeight: 0; NominalLength: 60; NominalWidth: 48; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.31; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: https://www.dolphinsolutions.co.uk/product/single-robe-hook-bc725/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 60 x 48 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC725; Uniclass2015Code: Pr_40_30_78_15; Uniclass2015Title: Clothes hooks; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC725
Type - Pset_ElementShading - Color: Brushed Satin or RALPowderCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ClothesHooks; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: Clothes hooks_BC725_DolphinSolutionsLimited; Category: Pr_40_30_78_15:Clothes hooks
Pset_DistributionFlowElementCommon - Reference: BC725:BC725; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Host: Level : Level 0
Dimensions - Area: 0.00466682 m2; Volume: 0.0000330174 m3
Other - Family: BC725: BC725; Family and Type: BC725: BC725; Type: BC725: BC725; Type Id: BC725: BC725
Phasing - Phase Created: New Construction
Name (BC725:BC725:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
468697 | 1400 | 150
468704 | 1050 | 157

# IfcFlowTerminal: DB3001:DB3001, DB3001:DB3001:468782
In: Level 0
Type - PredefinedType: SHOWER; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_76:Shower heads; CodePerformance: WRAS; Color: Various; Constituents: n/a; Description: UltraThinRoundShowerHead; DurationUnit: year; ExpectedLife: n/a; Features: 88Nozzles_6&9LitreFlowRegulators; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel_.5/PowderCoated_.6/CeramicCoated; Grade: 304; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DB3001; ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB3001; Name: ShowerHeads_WRAS_DB3001_UltraThinRoundShowerHead_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 44 mm; NominalWidth: 250 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-round-shower-head/; ReplacementCost: n/a; Shape: Rectangular; Size: 250x44; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3001; Uniclass2015Code: Pr_40_20_87_76; Uniclass2015Title: Shower heads; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3001
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB3001; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerHeads_WRAS_DB3001_UltraThinRoundShowerHead_DolphinSolutionsLimited; Category: Pr_40_20_87_76:Shower heads
Type - Pset_SanitaryTerminalTypeShower - Color: Various
Pset_DistributionFlowElementCommon - Reference: DB3001:DB3001; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 2250 mm; Host: Level : Level 0; Offset from Host: 2250 mm
Dimensions - Area: 0.0518063 m2; Volume: 0.000245526 m3
Identity Data - Mark: 188
Other - Family: DB3001: DB3001; Family and Type: DB3001: DB3001; Type: DB3001: DB3001; Type Id: DB3001: DB3001
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB3020:DB3020, DB3020:DB3020:468786
In: Level 0
Type - PredefinedType: SHOWER; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_76:Shower heads; CodePerformance: WRAS; Color: BrushedSatin/MirrorPolished; Constituents: n/a; Description: HandHeldShowerHead; DurationUnit: year; ExpectedLife: n/a; Features: 6&9LitreFlowRegulators; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel; Grade: 304; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DB3020; ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB3020; Name: ShowerHeads_WRAS_DB3020_HandHeldShowerHead_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 185 mm; NominalWidth: 23 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-hand-held-shower-head/; ReplacementCost: n/a; Size: 185x23; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3020; Uniclass2015Code: Pr_40_20_87_76; Uniclass2015Title: Shower heads; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3020
Type - Pset_ElementShading - Color: BrushedSatin/MirrorPolished
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB3020; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerHeads_WRAS_DB3020_HandHeldShowerHead_DolphinSolutionsLimited; Category: Pr_40_20_87_76:Shower heads
Type - Pset_SanitaryTerminalTypeShower - Color: BrushedSatin/MirrorPolished
Pset_DistributionFlowElementCommon - Reference: DB3020:DB3020; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 1220 mm; Host: Level : Level 0; Offset from Host: 1220 mm
Dimensions - Area: 0.00832223 m2; Volume: 0.0000782395 m3
Identity Data - Mark: 192
Other - Family: DB3020: DB3020; Family and Type: DB3020: DB3020; Type: DB3020: DB3020; Type Id: DB3020: DB3020
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB3041:DB3041, DB3041:DB3041:468785
In: Level 0
Type - PredefinedType: SHOWER; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: Brushed Satin; Constituents: n/a; Description: Shower hose; DurationUnit: year; ExpectedLife: n/a; Features: "1/2""BSP_connection_SS316"; Finish: Brushed Satin; Grade: 304; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DB3041; ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3041_ShowerHose; Name: ShowerFittingsPackage_WRAS_DB3041_ShowerHose_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalLength: 1500 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-stainless-steel-shower-hose/; ReplacementCost: n/a; Size: 1500 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3041; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3041
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3041_ShowerHose; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerFittingsPackage_WRAS_DB3041_ShowerHose_DolphinSolutionsLimited; Category: Pr_40_20_87_75:Shower fittings package
Type - Pset_SanitaryTerminalTypeShower - Color: Brushed Satin
Pset_DistributionFlowElementCommon - Reference: DB3041:DB3041; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 1220 mm; Host: Level : Level 0; Offset from Host: 1220 mm
Dimensions - Area: 0.0173889 m2; Volume: 0.000129094 m3
Identity Data - Mark: 191
Other - Family: DB3041: DB3041; Family and Type: DB3041: DB3041; Type: DB3041: DB3041; Type Id: DB3041: DB3041
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB3061:DB3061.350, DB3061:DB3061.350:468783
In: Level 0
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 350 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: BrushedSatin/MirrorPolished; Constituents: n/a; Description: Shower arm; DurationUnit: year; ExpectedLife: n/a; Features: Available in 4 lengths; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel; Grade: n/a; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass; ModelNumber: DB3061.300/DB3061.350/DB3061.400/DB3061.450; ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3061; Name: ShowerFittingsPackage_WRAS_DB3061_ShowerArm_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 0; NominalLength: 215 mm; NominalWidth: 0; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-shower-arm-2/; ReplacementCost: n/a; Shape: n/a; Size: 215 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3061.350; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: 2; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3061
Type - Pset_ElementShading - Color: BrushedSatin/MirrorPolished
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3061; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerFittingsPackage_WRAS_DB3061_ShowerArm_DolphinSolutionsLimited; Category: Pr_40_20_87_75:Shower fittings package
Pset_DistributionFlowElementCommon - Reference: DB3061:DB3061.350; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 2350 mm; Host: Level : Level 0; Offset from Host: 2350 mm
Dimensions - Area: 0.0165068 m2; Volume: 0.000155136 m3
Identity Data - Mark: 189
Other - Family: DB3061: DB3061.350; Family and Type: DB3061: DB3061.350; Type: DB3061: DB3061.350; Type Id: DB3061: DB3061.350
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB3073:Family1, DB3073:Family1:468784
In: Level 0
Type - PredefinedType: SHOWER; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: Various; Constituents: n/a; Description: Shower wall outlet and holder; DurationUnit: year; ExpectedLife: n/a; Features: "1/2""BSP_connection"; Finish: Suffix_.1/BrushedSatin_.2/PolishedStainlessSteel_.5/PowderCoated_.6/CeramicCoated; Grade: 304; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DB3073; ModelReference: ShowerFittingsPackages_DolphinSolutionsLimited_WRAS_DB3073; Name: ShowerFittingsPackages_WRAS_DB3073_ShowerWallOutletAndHolder_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 31 mm; NominalWidth: 68 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-shower-wall-outlet-and-holder-2/; ReplacementCost: n/a; Size: 31x68 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Family1; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3073
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackages_DolphinSolutionsLimited_WRAS_DB3073; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerFittingsPackages_WRAS_DB3073_ShowerWallOutletAndHolder_DolphinSolutionsLimited; Category: Pr_40_20_87_75:Shower fittings package
Type - Pset_SanitaryTerminalTypeShower - Color: Various
Pset_DistributionFlowElementCommon - Reference: DB3073:Family1; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 920 mm; Host: Level : Level 0; Offset from Host: 920 mm
Dimensions - Area: 0.00716927 m2; Volume: 0.0000498867 m3
Identity Data - Mark: 190
Other - Family: DB3073: Family1; Family and Type: DB3073: Family1; Type: DB3073: Family1; Type Id: DB3073: Family1
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB3090.450:DB3090.450, DB3090.450:DB3090.450:468787
In: Level 0
Type - PredefinedType: SHOWER; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: Brushed Satin; Constituents: n/a; Description: Shower slider rail and holder; DurationUnit: year; ExpectedLife: n/a; Finish: Brushed Satin; Grade: CZ121; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass; ModelNumber: DB3090.450; ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3090.450_ShowerSliderRailAndHolder; Name: ShowerFittingsPackage_WRAS_DB3090.450_ShowerSliderRailAndHolder_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 79 mm; NominalLength: 450mm; NominalWidth: 18 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-450mm-shower-slider-rail-and-holder/; ReplacementCost: n/a; Size: 18x450x79 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3090.450; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3090.450
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3090.450_ShowerSliderRailAndHolder; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerFittingsPackage_WRAS_DB3090.450_ShowerSliderRailAndHolder_DolphinSolutionsLimited; Category: Pr_40_20_87_75:Shower fittings package
Type - Pset_SanitaryTerminalTypeShower - Color: Brushed Satin
Pset_DistributionFlowElementCommon - Reference: DB3090.450:DB3090.450; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 1025 mm; Host: Level : Level 0; Offset from Host: 1025 mm
Dimensions - Area: 0.0274225 m2; Volume: 0.000227501 m3
Identity Data - Mark: 193
Other - Family: DB3090.450: DB3090.450; Family and Type: DB3090.450: DB3090.450; Type: DB3090.450: DB3090.450; Type Id: DB3090.450: DB3090.450
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC5083-11:BC5083-11, BC5083-11:BC5083-11:468694
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 1200 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_20_77:Shower curtain rails; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Shower curtain rails; DurationUnit: year; ExpectedLife: n/a; Features: Concealed fixings; Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-11; ModelReference: ShowerCurtainRails_DolphinSolutionsLimited_BC5083-11; Name: ShowerCurtainRails_BC5083-11_ShowerCurtainRail_DolphinSolutionsLimited; NBSDescription: Shower curtain rails; NBSReference: 45-35-70/334; NominalLength: 1200 mm; NominalWidth: 1200 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-corner-shower-rail/; ReplacementCost: n/a; Size: 1200x1200; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-11; Uniclass2015Code: Pr_40_30_20_77; Uniclass2015Title: Shower curtain rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-11
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_FurnitureTypeCommon - Description: Shower curtain rails
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainRails_DolphinSolutionsLimited_BC5083-11; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerCurtainRails_BC5083-11_ShowerCurtainRail_DolphinSolutionsLimited; Category: Pr_40_30_20_77:Shower curtain rails
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-11:BC5083-11
Constraints - Elevation from Level: 2025 mm; Host: Level : Level 0; Level: Level: Level 0; Moves With Nearby Elements: no; Offset from Host: 2025 mm
Dimensions - Area: 0.10303 m2; Volume: 0.00124196 m3
Identity Data - Mark: 147
Other - Family: BC5083-11: BC5083-11; Family and Type: BC5083-11: BC5083-11; Type: BC5083-11: BC5083-11; Type Id: BC5083-11: BC5083-11
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC5083-12:BC5083-12, BC5083-12:BC5083-12:468706
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_20_77:Shower curtain rails; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Shower curtain rail ceiling stay; DurationUnit: year; ExpectedLife: n/a; Features: Concealed fixings; Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-12; ModelReference: ShowerCurtainRails_CeilingStay_DolphinSolutionsLimited_BC5083-12; Name: ShowerCurtainRails_BC5083-12_ShowerCurtainRailCeilingStay_DolphinSolutionsLimited; NBSDescription: Shower curtain rails; NBSReference: 45-35-70/334; NominalHeight: 500 mm; NominalWidth: 75 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-ceiling-stay/; ReplacementCost: n/a; Size: 75x500; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-12; Uniclass2015Code: Pr_40_30_20_77; Uniclass2015Title: Shower curtain rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-12
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_FurnitureTypeCommon - Description: Shower curtain rail ceiling stay
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainRails_CeilingStay_DolphinSolutionsLimited_BC5083-12; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerCurtainRails_BC5083-12_ShowerCurtainRailCeilingStay_DolphinSolutionsLimited; Category: Pr_40_30_20_77:Shower curtain rails
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-12:BC5083-12
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 2500 mm; Host: Level : Level 0; Offset from Host: 2500 mm
Dimensions - Area: 0.00895278 m2; Volume: 0.0000298871 m3
Identity Data - Mark: 159
Other - Family: BC5083-12: BC5083-12; Family and Type: BC5083-12: BC5083-12; Type: BC5083-12: BC5083-12; Type Id: BC5083-12: BC5083-12
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC5083-13:BC5083-13 (24)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; CodePerformance: n/a; Color: Chrome; Constituents: n/a; Description: Shower curtain hooks; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Chrome Plated; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass Chrome Plated; ModelNumber: BC5083-13; ModelReference: ShowerCurtainHooks_DolphinSolutionsLimited_BC5083-13; Name: ShowerCurtainHooks_BC5083-13_DolphinSolutionsLimited; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-curtain-hooks-brass-chrome-plated/; ReplacementCost: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-13; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-13
Type - Pset_ElementShading - Color: Chrome
Type - Pset_FurnitureTypeCommon - Description: Shower curtain hooks
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainHooks_DolphinSolutionsLimited_BC5083-13; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerCurtainHooks_BC5083-13_DolphinSolutionsLimited
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-13:BC5083-13
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 2025 mm; Host: Level : Level 0; Offset from Host: 2025 mm
Dimensions - Area: 0.0013773 m2; Volume: 0.00000205534 m3
Other - Family: BC5083-13: BC5083-13; Family and Type: BC5083-13: BC5083-13; Type: BC5083-13: BC5083-13; Type Id: BC5083-13: BC5083-13
Phasing - Phase Created: New Construction
Name (BC5083-13:BC5083-13:...) | Mark
468789 | 195
468790 | 196
468791 | 197
468792 | 198
468793 | 199
468794 | 200
468795 | 201
468796 | 202
468797 | 203
468798 | 204
468799 | 205
468800 | 206
468802 | 208
468803 | 209
468804 | 210
468805 | 211
468806 | 212
468807 | 213
468808 | 214
468809 | 215
468810 | 216
468811 | 217
468812 | 218
468813 | 219

# IfcFurnishingElement: BC5083-14:BC5083-14 (2)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; CodePerformance: n/a; Color: White; Constituents: n/a; Description: Shower curtain; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: 4oz Weighted White Polyester; ModelNumber: BC5083-14; ModelReference: ShowerCurtain_DolphinSolutionsLimited_BC5083-14; Name: ShowerCurtain_BC5083-14_DolphinSolutionsLimited; NominalHeight: 1830 mm; NominalLength: 1830 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-curtain/; ReplacementCost: n/a; Size: 1830x1830; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-14; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-14
Type - Pset_ElementShading - Color: White
Type - Pset_FurnitureTypeCommon - Description: Shower curtain
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtain_DolphinSolutionsLimited_BC5083-14; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerCurtain_BC5083-14_DolphinSolutionsLimited
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-14:BC5083-14
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 125 mm; Host: Level : Level 0; Offset from Host: 125 mm
Dimensions - Area: 1.91829 m2; Volume: 0.00191533 m3
Other - Family: BC5083-14: BC5083-14; Family and Type: BC5083-14: BC5083-14; Type: BC5083-14: BC5083-14; Type Id: BC5083-14: BC5083-14
Phasing - Phase Created: New Construction
Name (BC5083-14:BC5083-14:...) | Mark
468788 | 194
468801 | 207

# IfcFurnishingElement: BC5083-33:BC5083-33, BC5083-33:BC5083-33:468696
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_06_83:Shower seats; CodePerformance: BSEN12182; Color: Pale grey_white metal; Constituents: n/a; Description: Shower seat; DurationUnit: year; ExpectedLife: n/a; Finish: n/a; IfcExportAs: IfcFurnitureType; IfcExportType: CHAIR; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: DiecastAluminium_VacuumMouldedPolyethylene; ModelNumber: BC5083-33; ModelReference: ShowerSeats_DolphinSolutionsLimited_BC5083-33_ShowerSeat; Name: ShowerSeats_BC5083-33_ShowerSeat_DolphinSolutionsLimited; NBSDescription: Shower seats; NBSReference: 45-35-72/352; NominalHeight: 220 mm; NominalLength: 650 mm; NominalWidth: 450 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.11.17; OmniClass Number: 23.45.05.14.11.17; OmniClass Title: Shower/Bath Seats; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-seat/; ReplacementCost: n/a; Shape: Rectangular; Size: 450x650x220; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-33; Uniclass2015Code: Pr_40_20_06_83; Uniclass2015Title: Shower seats; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-33
Type - Pset_ElementShading - Color: Pale grey_white metal
Type - Pset_FurnitureTypeCommon - Description: Shower seat
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerSeats_DolphinSolutionsLimited_BC5083-33_ShowerSeat; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerSeats_BC5083-33_ShowerSeat_DolphinSolutionsLimited; Category: Pr_40_20_06_83:Shower seats
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-33:BC5083-33
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 485 mm; Host: Level : Level 0; Offset from Host: 485 mm
Dimensions - Area: 0.372725 m2; Volume: 0.0101955 m3
Identity Data - Mark: 149
Other - Family: BC5083-33: BC5083-33; Family and Type: BC5083-33: BC5083-33; Type: BC5083-33: BC5083-33; Type Id: BC5083-33: BC5083-33
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC5083-34:BC5083-34, BC5083-34:BC5083-34:468695
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_06_83:Shower seats; Color: Pale grey_white metal; Constituents: n/a; Description: Shower seat back rest; DurationUnit: year; ExpectedLife: n/a; Finish: n/a; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: DiecastAluminium_VacuumMouldedPolyethylene; ModelNumber: BC5083-34; ModelReference: ShowerSeat_DolphinSolutionsLimited_BC5083-34_ShowerSeatBackRest; Name: ShowerSeat_BC5083-34_ShowerSeatBackRest_DolphinSolutionsLimited; NBSDescription: Shower seats; NBSReference: 45-35-72/352; NominalHeight: 189 mm; NominalLength: 160 mm; NominalWidth: 450 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.11.17; OmniClass Number: 23.45.05.14.11.17; OmniClass Title: Shower/Bath Seats; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-back-rest/; ReplacementCost: n/a; Shape: Rectangular; Size: 450x160x189; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-34; Uniclass2015Code: Pr_40_20_06_83; Uniclass2015Title: Shower seats; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-34
Type - Pset_ElementShading - Color: Pale grey_white metal
Type - Pset_FurnitureTypeCommon - Description: Shower seat back rest
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerSeat_DolphinSolutionsLimited_BC5083-34_ShowerSeatBackRest; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerSeat_BC5083-34_ShowerSeatBackRest_DolphinSolutionsLimited; Category: Pr_40_20_06_83:Shower seats
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-34:BC5083-34
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 820 mm; Host: Level : Level 0; Offset from Host: 820 mm
Dimensions - Area: 0.152202 m2; Volume: 0.00723579 m3
Identity Data - Mark: 148
Other - Family: BC5083-34: BC5083-34; Family and Type: BC5083-34: BC5083-34; Type: BC5083-34: BC5083-34; Type Id: BC5083-34: BC5083-34
Phasing - Phase Created: New Construction

# IfcRailing: BC5063-05:BC5063-05, BC5063-05:BC5063-05:468814
In: Level 0
Type - PredefinedType: HANDRAIL; Material: <Unnamed>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - Heigth: 92 mm; Length: 500 mm; Width: 32 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CAWS: N13/69 Support rails and grab bars_N13/436 Handrails and grab bars; CodePerformance: BSEN12182; Color: Brushed Satin_Various; Constituents: n/a; Description: 500mm long roseless 32mm grab rail; DurationUnit: year; ExpectedLife: n/a; Features: Roseless 60mm wall clearance; Finish: Brushed Satin_Suffix.5-PowderCoated_.6-CeramicCoated; Form: Wall-mounted; Grade: 304; IfcExportAs: IfcRailingType; IfcExportType: HANDRAIL; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; Material: StainlessSteel; ModelNumber: BC5063-05; ModelReference: DolphinSolutionsLimited_Roseless32mmGrabRail; Name: SupportRails_Roseless32mmGrabRail_BC5063-05_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 92 mm; NominalLength: 500 mm; NominalWidth: 32 mm; ObjectClassification: 23.40.20.27.14; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: BC5063-05; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 500 x 32 x 92 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5063-05; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5063-05
Type - Pset_ElementShading - Color: Brushed Satin_Various
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Roseless32mmGrabRail; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_PrecastConcreteElementGeneral - SerialNumber: n/a
Type - Pset_ProductRequirements - Name: SupportRails_Roseless32mmGrabRail_BC5063-05_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Type - Pset_RailingCommon - IsExternal: no
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5063-05:BC5063-05
Pset_RailingCommon - Reference: BC5063-05:BC5063-05
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 664.516 mm; Host: Level : Level 0; Offset from Host: 664.516 mm
Dimensions - Area: 0.0310315 m2; Volume: 0.000483638 m3
Identity Data - Mark: 220
Other - Family: BC5063-05: BC5063-05; Family and Type: BC5063-05: BC5063-05; Type: BC5063-05: BC5063-05; Type Id: BC5063-05: BC5063-05
Phasing - Phase Created: New Construction
